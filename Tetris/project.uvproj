# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay1ms.c Delay1ms.h MatrixLED.c MatrixLED.h Timer0.c Timer0.h UART.c UART.h Int0.c Int0.h IR.c IR.h Timer2.c Timer2.h Tetris.c Tetris.h
